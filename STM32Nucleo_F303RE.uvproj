# Keil uVision project STM32Nucleo_F303RE.uvproj, settings and files
target F303RE_SRAM (ARM-ADS)
  device: STM32F303RE STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(72000000) ELITTLE
  output: STM32Nucleo_F303RE +hex
  c flags: Optim=2
  c define: USE_STDPERIPH_DRIVER,STM32F303xE ,VECT_TAB_SRAM
  c include: .\src
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0xa000
  memory RVCT9: RAM 0x2000a000 size 0x6000
  group User
    ./src/: main.cpp OLED_DISPLAY.cpp OLED_DRIVER.cpp
  group Libraries
    ./src/: stm32f30x_gpio.c stm32f30x_rcc.c stm32f30x_syscfg.c
  group Startup
    ./src/: system_stm32f30x.c startup_stm32f303xe.s
target FLASH (ARM-ADS)
  device: STM32F303RE STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: as above
  output: STM32Nucleo_F303RE +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,VECT_TAB_FLASH
  c include: .\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
